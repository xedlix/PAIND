<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>240000</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0</value></param>
<param><key>audio_decim</key><value>5</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>240000</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>0</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>60</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>90875000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>analog_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
